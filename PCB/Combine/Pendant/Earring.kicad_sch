File: PCB/Combine/Pendant/Earring.kicad_sch (KiCad schematic)
At the start: 5 parts

Commit message: Adding some renders
Other:
- company: (none) -> DK
- title: (none) -> BLEarrings V1

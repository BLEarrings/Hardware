File: PCB/Combine/Combine.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Adding some renders
Other:
- company: (none) -> DK
- title: (none) -> BLEarrings V1
